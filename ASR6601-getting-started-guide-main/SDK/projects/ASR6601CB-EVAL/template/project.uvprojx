# Keil uVision project project.uvprojx, settings and files
target project (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ESEL ELITTLE
  output: project +hex
  AfterMake: .\utils\genbinary.bat
  group platform
    ../../../platform/system/: system_cm4.c startup_cm4.S
    ../../../: printf-stdarg.c
  group drivers
    ../../../drivers/peripheral/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_uart.c tremo_wdg.c
  group user
    ../../../projects/ASR6601CB-EVAL/template/src/: main.c tremo_it.c
    ./src/: classA.c strToHex.c set_tx_duty_cycle_time.c gwlog.c iic.c ads1115.c bh1750.c sgp30.c dht11.c sha256.c genTriplet.c
  group lora
    ../../../lora/system/: delay.c timer.c
    ../../../lora/system/crypto/: cmac.c
    ../../../lora/radio/sx126x/: radio.c sx126x.c
    ../../../lora/driver/: rtc-board.c sx1262-board.c utilities.c
    ../../../lora/mac/: LoRaMac.c LoRaMacClassB.c LoRaMacConfirmQueue.c LoRaMacCrypto.c
    ../../../lora/mac/region/: Region.c RegionCommon.c RegionCN470.c
  group lib
    ../../../drivers/crypto/lib/: libcrypto.a
